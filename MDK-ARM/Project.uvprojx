# Keil uVision project Project.uvprojx, settings and files
target STM32F4-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4-Discovery +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --C99
  c include: ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\BSP\STM32F4-Discovery;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c Keypad.c LCD.c LED.c Wifi.c USRAT.c Timer.c Flash.c spi_flash.c
software components: CMSIS:CORE 5.1.1, Compiler:Event Recorder 1.4.0, Compiler:I/O:TTY 1.4.0, CMSIS Driver:SPI 2.11, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:Flash 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:I2S 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:STM32Cube HAL:USART 1.7.4, Device:Startup 2.6.2
